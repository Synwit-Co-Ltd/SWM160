# Keil uVision project SWM160_StdPeriph_Driver.uvproj, settings and files
target SWM160 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SWM160_stdperiph_lib +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM160_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM160_StdPeriph_Driver/: SWM160_adc.c SWM160_exti.c SWM160_gpio.c SWM160_i2c.c SWM160_pwm.c SWM160_timr.c SWM160_uart.c SWM160_wdt.c SWM160_flash.c SWM160_port.c SWM160_spi.c SWM160_dma.c SWM160_can.c SWM160_div.c SWM160_rtc.c SWM160_sleep.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM160.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM160.s
