# Keil uVision project RTX_CMSIS.uvprojx, settings and files
target SWM160 (ARM-ADS)
  device: SWM160x8 Synwit
  pack: Synwit.SWM32_DFP.1.7.1
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RTX_CMSIS
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./APP/: main.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:Driver:ADC 1.0.1, Device:Driver:GPIO 1.0.1, Device:Driver:PWM 1.0.1, Device:Driver:Port 1.0.1, Device:Driver:Timer 1.0.1, Device:Driver:UART 1.0.1, Device:Startup 1.6.0
