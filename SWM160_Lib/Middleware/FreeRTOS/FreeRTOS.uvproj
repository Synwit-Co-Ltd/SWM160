# Keil uVision project FreeRTOS.uvproj, settings and files
target SWM160 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: FreeRTOS
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2
  c include: ..\..\SWM160_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM160_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM160_StdPeriph_Driver\CSL\SWM160_StdPeriph_Driver;.\APP\FreeRTOS;.\APP\FreeRTOS\port_MDK
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c
    ./APP/FreeRTOS/heap/: heap_1.c
    ./APP/FreeRTOS/port_MDK/: port.c
  group CSL\StdPD
    ../../SWM160_StdPeriph_Driver/CSL/SWM160_StdPeriph_Driver/: SWM160_adc.c SWM160_exti.c SWM160_gpio.c SWM160_i2c.c SWM160_pwm.c SWM160_timr.c SWM160_uart.c SWM160_wdt.c SWM160_can.c SWM160_div.c SWM160_dma.c SWM160_flash.c SWM160_port.c SWM160_spi.c SWM160_rtc.c
  group CSL\CMSIS
    ../../SWM160_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM160.c
    ../../SWM160_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM160.s
