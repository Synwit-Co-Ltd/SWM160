# IAR project FreeRTOS.ewp, settings and files
configuration SWM160 (ARM, debug)
  General.OGChipSelectEditMenu: SWM240x8 Synwit SWM240x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM160_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM160_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM160_StdPeriph_Driver\CSL\SWM160_StdPeriph_Driver; .\APP\FreeRTOS; .\APP\FreeRTOS\port_IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: APP/FreeRTOS
  OBJCOPY.OOCOutputFile: SWM2400_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CSL_StdPD
    ../../SWM160_StdPeriph_Driver/CSL/SWM160_StdPeriph_Driver/: SWM160_gpio.c SWM160_div.c SWM160_timr.c SWM160_can.c SWM160_spi.c SWM160_pwm.c SWM160_dma.c SWM160_adc.c SWM160_uart.c SWM160_exti.c SWM160_wdt.c SWM160_i2c.c SWM160_port.c SWM160_flash.c SWM160_rtc.c
  group CSL_CMSIS
    ../../SWM160_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM160.s
    ../../SWM160_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM160.c
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: tasks.c queue.c list.c
    ./APP/FreeRTOS/port_IAR/: port.c portasm.s
    ./APP/FreeRTOS/heap/: heap_1.c
